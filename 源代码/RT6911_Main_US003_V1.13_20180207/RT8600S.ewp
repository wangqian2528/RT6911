# IAR project RT8600S.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32LG280F128 EnergyMicro EFM32LG280F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32LG280F128
  ICCARM.CCIncludePath2: ; Include\; BL\; emlib\inc\; CMSIS\CoreSupport\; CMSIS\DeviceSupport\EFM32LG\Include\; CMSIS\DeviceSupport\EFM32LG\Source\; CMSIS\DeviceSupport\EFM32LG\Source\IAR\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RT6911_Main_US003_V1.13_20181018_OQC.bin
  ILINK.IlinkOutputFile: RT8600_New.out
  ILINK.IlinkIcfFile: RT8600S.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group CMSIS
    CMSIS/DeviceSupport/EFM32LG/Source/IAR/: startup_efm32lg.s
    CMSIS/DeviceSupport/EFM32LG/Source/: system_efm32lg.c
  group EFM32lib
    emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group Local
    ./: main.c system.c
  group Peripheral
    ./: ADC_scan.c AxisMotor.c BackPad.c BlueTooth.c DMA_Ctrl.c Flex_Uart .c HandUart.c IndicateLED.c Input.c KneadMotor.c KnockMotor_8840.c LegKnead_Uart.c LegMotor.c LEUart_DMA.c memory.c Mp3Ctrl.c Power.c problem.c Roller_Uart.c SlideMotor.c UartLeg.c Valve.c VoiceUart.c WaistHot.c WalkMotor.c waver_Flex_Motor.c xmodem.c
    Debug/Exe/: led_Lib.a
  group Software
    ./: Data_Cul.c MassageStatus.c Timer.c
