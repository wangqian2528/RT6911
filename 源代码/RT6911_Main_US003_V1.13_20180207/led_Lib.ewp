# IAR project led_Lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32LG280F128 EnergyMicro EFM32LG280F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32LG280F128
  ICCARM.CCIncludePath2: ; Include\; BL\; emlib\inc\; CMSIS\CoreSupport\; CMSIS\DeviceSupport\EFM32LG\Include\; CMSIS\DeviceSupport\EFM32LG\Source\; CMSIS\DeviceSupport\EFM32LG\Source\IAR\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: led_Lib.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: LED_RGB.c
